# Keil uVision project MediaCenter.uvprojx, settings and files
target LPC1768 Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MediaCenter
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c misc: --diag_suppress 550
  c include: .\Images;.\common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Code
    ./: main.c menu.c menu.h photo_gallery.c photo_gallery.h audio_player.c audio_player.h game_center.c game_center.h
  group Utilities
    ./: state.h GLCD_SPI_LPC1700.c LED.c GLCD.h KBD.c KBD.h
  group Audio
    ./: adcuser.c usbcore.c usbdesc.c usbhw.c usbuser.c core_cm3.c
  group Pictures
    ./Images/: tictactoe_o.c tictactoe_x.c arrow.c falcon9.c saturnv.c starship.c
  group Games
    ./: tictactoe.c tictactoe.h
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS:Keil RTX 4.82.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
